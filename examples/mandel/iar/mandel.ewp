# IAR project mandel.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32GG990F1024 EnergyMicro EFM32GG990F1024
  ICCARM.CCDefines: EFM32GG990F1024; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\EnergyMicro\EFM32GG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config; ..; ..\..\..\..\..\reptile\glib
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mandel.bin
  ILINK.IlinkOutputFile: mandel.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32GG990F1024.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG990F1024; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../Device/EnergyMicro/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../../../../../Device/EnergyMicro/EFM32GG/Source/: system_efm32gg.c
  group BSP
    ../../../../common/bsp/: bsp_dk_3201.c bsp_trace.c
  group Graphics
    ../../../../../reptile/glib/dmd/ssd2119/: dmd_ssd2119_direct.c
  group Drivers
    ../../../../common/drivers/: tftspi.c tftdirect.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_dbg.c em_ebi.c em_emu.c em_gpio.c em_rmu.c em_system.c em_usart.c
  group Source
    ../: mandel.c

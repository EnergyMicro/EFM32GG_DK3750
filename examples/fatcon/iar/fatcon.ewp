# IAR project fatcon.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32GG990F1024 EnergyMicro EFM32GG990F1024
  ICCARM.CCDefines: EFM32GG990F1024; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\EnergyMicro\EFM32GG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\common\drivers; ..\..\..\..\common\bsp; ..\..\..\config; ..\..\..\..\..\reptile\fatfs\inc; ..\..\..\..\..\reptile\glib
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: fatcon.bin
  ILINK.IlinkOutputFile: fatcon.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32GG990F1024.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG990F1024; DEBUG_EFM
  group bsp
    ../../../../common/bsp/: bsp_dk_3201.c bsp_trace.c
  group drivers
    ../../../../common/drivers/: retargetio.c retargetserial.c microsd.c
  group CMSIS
    ../../../../../Device/EnergyMicro/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../../../../../Device/EnergyMicro/EFM32GG/Source/: system_efm32gg.c
  group emlib
    ../../../../../emlib/src/: em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_int.c em_system.c em_usart.c
  group FatFS
    ../../../../../reptile/fatfs/src/: diskio.c ff.c
  group Source
    ../: fatcon.c
